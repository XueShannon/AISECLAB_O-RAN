options:
  parameters:
    generate_options: qt_gui
    id: CSI_GNU_RX
    output_language: python
    title: CSI_GNU_RX
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 25e6
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class csi_calculator(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="CSI Calculator",
                  in_sig=[np.complex64],
                  out_sig=[np.float32, np.float32, np.float32])
          
          def calculate_snr(self, signal, noise):
              signal_power = np.mean(np.abs(signal)**2)
              noise_power = np.mean(np.abs(noise)**2)
              snr = 10 * np.log10(signal_power / noise_power)
              return snr
          
          def estimate_doppler_shift(self, received_signal, sample_rate):
              frequency_spectrum = np.fft.fft(received_signal)
              frequency_bins = np.fft.fftfreq(len(received_signal), d=1/sample_rate)
              peak_index = np.argmax(np.abs(frequency_spectrum))
              doppler_shift = frequency_bins[peak_index]
              return doppler_shift
          
          def calculate_delay_spread(self, received_signal, sample_rate):
              correlation = np.correlate(received_signal, received_signal, mode='full')
              power_delay_profile = np.abs(correlation)**2
              delay_indices = np.arange(len(power_delay_profile)) / sample_rate
              mean_delay = np.sum(delay_indices * power_delay_profile) / np.sum(power_delay_profile)
              mean_square_delay = np.sum((delay_indices**2) * power_delay_profile) / np.sum(power_delay_profile)
              delay_spread = np.sqrt(mean_square_delay - mean_delay**2)
              return delay_spread
          
          def work(self, input_items, output_items):
              received_signal = input_items[0]
              noise = received_signal - np.mean(received_signal)  
              
              snr = self.calculate_snr(received_signal, noise)
              doppler_shift = self.estimate_doppler_shift(received_signal, sample_rate=25e6) 
              delay_spread = self.calculate_delay_spread(received_signal, sample_rate=25e6)  
              
              output_items[0][:] = snr
              output_items[1][:] = doppler_shift
              output_items[2][:] = delay_spread
              return len(output_items[0])



      gr.basic_block_csi_calculator = csi_calculator
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Magnitude
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Phase
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: SNR
  states: {}
- name: qtgui_time_sink_x_3_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Doppler Shift
  states: {}
- name: qtgui_time_sink_x_3_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Delay Spread
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 25e6
    center_freq0: 3435e6
    dev_args: '"serial=30982F4"'
    gain0: '30'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_complex_to_magphase_0, '0', blocks_rms_xx_0, '0']
- [blocks_complex_to_magphase_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_1, '0']
- [blocks_rms_xx_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [blocks_throttle2_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_3, '0']
- [epy_block_0, '1', qtgui_time_sink_x_3_0, '0']
- [epy_block_0, '2', qtgui_time_sink_x_3_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
